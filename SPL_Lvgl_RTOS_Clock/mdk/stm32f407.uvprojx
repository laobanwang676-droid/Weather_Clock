# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f407 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: stm32f407
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,LV_LVGL_H_INCLUDE_SIMPLE
  c include: ..\app;..\app\font;..\app\page;..\app\image;..\app\weather;..\driver\esp32;..\driver\rtc;..\driver\aht20;..\driver\st7789;..\driver\console;..\driver\usart3;..\driver\tim_delay;..\driver\lvgl_ui;..\firmware\driver\inc;..\firmware\cmsis\core;..\firmware\cmsis\device;..\third_lib\freertos\include;..\third_lib\freertos\portable;..\driver\lvgl;..\driver\lvgl\src;..\driver\lvgl\src\config;..\driver\lvgl\src\porting;..\driver\lvgl\src\widgets;..\driver\lvgl\src\font
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c board.c app_work.c work_queue.c
    ../app/weather/: weather.c
  group driver
    ../driver/esp32/: esp32.c
    ../driver/aht20/: aht20.c
    ../driver/st7789/: st7789.c ui.c
    ../driver/console/: console.c
    ../driver/rtc/: rtc.c
    ../driver/tim_delay/: tim_delay.c
    ../driver/usart3/: usart3.c
    ../driver/lvgl_ui/: lvgl_ui.c
  group firmware/comsis
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group third_lib/freertos
    ../third_lib/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group third_lib/protable
    ../third_lib/freertos/portable/: heap_4.c port.c
  group lvgl/config
    ../driver/lvgl/src/config/: lv_conf.h lvgl.h
  group lvgl/core
    ../driver/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/draw
    ../driver/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../driver/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../driver/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../driver/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../driver/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../driver/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../driver/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../driver/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../driver/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl/extra
    ../driver/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../driver/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../driver/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../driver/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../driver/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../driver/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../driver/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../driver/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../driver/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../driver/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../driver/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../driver/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../driver/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../driver/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../driver/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../driver/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../driver/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../driver/lvgl/src/extra/others/msg/: lv_msg.c
    ../driver/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../driver/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../driver/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../driver/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../driver/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../driver/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../driver/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../driver/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../driver/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../driver/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../driver/lvgl/src/extra/widgets/led/: lv_led.c
    ../driver/lvgl/src/extra/widgets/list/: lv_list.c
    ../driver/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../driver/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../driver/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../driver/lvgl/src/extra/widgets/span/: lv_span.c
    ../driver/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../driver/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../driver/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../driver/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../driver/lvgl/src/extra/widgets/win/: lv_win.c
    ../driver/lvgl/src/extra/: lv_extra.c
  group lvgl/font
    ../driver/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c dejavu_sans_mono_48.c
  group lvgl/hal
    ../driver/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/misc
    ../driver/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/porting
    ../driver/lvgl/src/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group lvgl/widgets
    ../driver/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
